# Keil uVision project board_stm32f103c8t6.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: board_stm32f103c8t6
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ..\cubemx_gen\Core\Inc;..\cubemx_gen\Drivers\STM32F1xx_HAL_Driver\Inc;..\cubemx_gen\Drivers\STM32F1xx_HAL_Driver\Inc\Legacy;..\cubemx_gen\Drivers\CMSIS\Device\ST\STM32F1xx\Include;..\cubemx_gen\Drivers\CMSIS\Include;..\Core\config;..\Core\tasks;..\Core\app;..\Drivers;..\Middleware;..\User;..\FreeRTOS\include;..\FreeRTOS\portable;..\FreeRTOS
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup
    ./: startup_stm32f103xb.s
  group CubeMX_HAL_Driver
    ../cubemx_gen/Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_can.c stm32f1xx_hal_cec.c stm32f1xx_hal_cortex.c stm32f1xx_hal_crc.c stm32f1xx_hal_dac.c stm32f1xx_hal_dac_ex.c stm32f1xx_hal_dma.c stm32f1xx_hal_eth.c stm32f1xx_hal_exti.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_hcd.c stm32f1xx_hal_i2c.c stm32f1xx_hal_i2s.c stm32f1xx_hal_irda.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_mmc.c stm32f1xx_hal_nand.c stm32f1xx_hal_nor.c stm32f1xx_hal_pccard.c stm32f1xx_hal_pcd.c stm32f1xx_hal_pcd_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_sd.c stm32f1xx_hal_smartcard.c stm32f1xx_hal_spi.c stm32f1xx_hal_sram.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_wwdg.c stm32f1xx_ll_adc.c stm32f1xx_ll_crc.c stm32f1xx_ll_dac.c stm32f1xx_ll_dma.c stm32f1xx_ll_exti.c stm32f1xx_ll_fsmc.c stm32f1xx_ll_gpio.c stm32f1xx_ll_i2c.c stm32f1xx_ll_pwr.c stm32f1xx_ll_rcc.c stm32f1xx_ll_rtc.c stm32f1xx_ll_sdmmc.c stm32f1xx_ll_spi.c stm32f1xx_ll_tim.c stm32f1xx_ll_usart.c stm32f1xx_ll_usb.c stm32f1xx_ll_utils.c
  group CubeMX_Gen_Core
    ../cubemx_gen/Core/Src/: gpio.c main.c stm32f1xx_hal_msp.c stm32f1xx_hal_timebase_tim.c stm32f1xx_it.c system_stm32f1xx.c usart.c dma.c tim.c
  group App_Config
    ../Core/config/: board_config.h task_config.h task_handle.h
  group Ext_Driver
    ../Drivers/: ext_gpio_key.c ext_uart_esp.c ext_gpio_led.c ext_pwm_led.c ext_pwm_motor.c ext_pwm_servo.c
  group Middleware
    ../Middleware/: ring_buffer.c protocol_frame.c
  group App_Business
    ../Core/app/: device_logic.c
  group App_Tasks
    ../Core/tasks/: task_debug.c task_key.c task_led.c task_esp.c task_actuator.c
  group System_Init
    ../User/: system_init.c
  group FreeRTOS_Kernel
    ../FreeRTOS/: FreeRTOSConfig.h
    ../FreeRTOS/source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../FreeRTOS/portable/: heap_4.c port.c
